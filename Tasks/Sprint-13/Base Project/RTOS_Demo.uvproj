# Keil uVision project RTOS_Demo.uvproj, settings and files
target RTOSDemo_ARM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: RTOS_Demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS
  c include: .;.\FreeRTOS;.\FreeRTOS\Source\portable\RVDS\ARM7_LPC21xx;.\header;.\FreeRTOS\Demo\Common\include;.\FreeRTOS\Source\include;.\lib
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Other
    ./: Startup.s
    ./ParTest/: ParTest.c
    ./source/: GPIO.c GPIO_cfg.c main.c serial.c
    ./serial/: serialISR.s
  group FreeRTOS
    ./FreeRTOS/Source/: list.c queue.c tasks.c
    ./FreeRTOS/Source/portable/MemMang/: heap_2.c
    ./FreeRTOS/Source/portable/RVDS/ARM7_LPC21xx/: port.c portASM.s
target RTOSDemo_THUMB (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2129 NXP (founded by Philips)
  cpu: as above
  output: RTOSDemo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM7_LPC21xx_KEIL_RVDS KEIL_THUMB_INTERWORK
  c include: .;..\..\Source\portable\RVDS\ARM7_LPC21xx;..\..\..\..\..\..\Starter_Files_V1\Starter_Files_V1\header;..\Common\include;..\..\Source\include;..\..\..\..\..\..\Starter_Files_V1\Starter_Files_V1\lib
  asm include: ..\..\Source\portable\RVDS\ARM7_LPC21xx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
